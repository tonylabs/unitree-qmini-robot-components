Commit message: Commit qmini_description for ROS2

File: qmini_description/Qmini.urdf (robot description, URDF)
Before this commit: robot Qmini, 12 links, 11 joints
Links:
- removed link world
Joints:
- removed joint floating_base_joint
